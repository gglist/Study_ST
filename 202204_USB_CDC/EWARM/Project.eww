<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\202204_USB_CDC.ewp</path>
  </project>
  <batchBuild />
</workspace>
